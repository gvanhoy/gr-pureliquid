<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>pureliquid_file_sink</key>
<param><key>id</key><value>pureliquid_file_sink_0</value></param>
<param><key>file_name</key><value>/home/gvanhoy/Desktop/message_received.txt</value></param>
</block>
<block>
<key>pureliquid_file_source</key>
<param><key>id</key><value>pureliquid_file_source_0</value></param>
<param><key>comment</key><value>Stores a whole file into a buffer. 
Sends a message with the files entire
contents periodically.</value></param>
<param><key>file_name</key><value>/home/gvanhoy/Desktop/message.txt</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>period_ms</key><value>1000</value></param>
</block>
<block>
<key>pureliquid_flex_rx</key>
<param><key>id</key><value>pureliquid_flex_rx_0</value></param>
</block>
<block>
<key>pureliquid_flex_tx</key>
<param><key>id</key><value>pureliquid_flex_tx_0</value></param>
<param><key>inner_code</key><value>0</value></param>
<param><key>modulation</key><value>0</value></param>
<param><key>outer_code</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>msg_complex</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pureliquid_flex_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pureliquid_file_source_0</source_block_id><sink_block_id>pureliquid_flex_tx_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pureliquid_flex_rx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>constellation</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pureliquid_flex_rx_0</source_block_id><sink_block_id>pureliquid_file_sink_0</sink_block_id><source_key>payload_data</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pureliquid_flex_tx_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>pdus</source_key><sink_key>schedule_event</sink_key></connection>
</flow_graph>
